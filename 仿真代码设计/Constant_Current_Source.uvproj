# Keil uVision project Constant_Current_Source.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: Constant_Current_Source +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\start;.\myware\LCD_1602;.\myware\MAX1241;.\myware\MCP4921;.\myware\TIM;.\myware\KEY;.\myware\Filter;.\myware\TLC0832
  group Source Group 1
    ./: STARTUP.A51
  group start
    ./start/: main.c public.c
  group APP
    ./myware/LCD_1602/: LCD1602.c
    ./myware/MAX1241/: MAX1241.c
    ./myware/MCP4921/: MCP4921.c
    ./myware/TIM/: Tim.c
    ./myware/KEY/: KEY.c
    ./myware/TLC0832/: TLC0832.c
